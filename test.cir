Test Circuit
C1 2 0 10u
V1 1 0 SINE(0 0 1k) ac 1
.control
ac dec 10 1 100k
print v(2)
.endc
