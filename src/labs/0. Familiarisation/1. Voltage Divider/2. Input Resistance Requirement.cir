*
R1 0 0 1k
R2 2 a 100k
R3 2 0 100k
R4 0 0 10k
R5 0 0 500k
R6 0 0 500k
R7 0 0 1k
R8 0 0 10k
RAmmeter 2 1 1m
V1 a 0 5
* INSTRUCTIONS: Configure the source to produce 5V DC, and construct a simple voltage divider circuit with input resistance seen from the source > 100kOhms and < 500kOhms. The voltage divider should produce 2.5V at the intermediate node. Simulate the circuit to validate your results
.control
tran 50u 500m
run
print v(2) v(1)
.endc
