*
R1 1 0 1k
V1 1 0 SINE(0,1,1k)
* INSTRUCTIONS: Configure the source to produce 5V DC, and construct a simple voltage divider circuit that produces 3V at the intermediate node. Simulate the circuit to validate your results
* ACTION FUNCTION: Familiarisation
.control
tran 1u 5m
run
print v(1)
.endc
