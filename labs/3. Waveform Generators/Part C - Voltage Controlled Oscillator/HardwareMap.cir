*** Basic Setup ***
XA 5 2 4 11 1 LM741
XB 0 6 4 11 7 LM741
XC 10 0 4 11 8 LM741
XD 0 13 4 11 14 LM741
RVariable1 4 5 10k
RVariable2 5 0 10k
C1 6 8 10p
Rx11 7 10 1k
Rx12 7 10 1k
Rx13 7 10 1k
Rx14 7 10 1k
Rx15 7 10 1k
Rx16 7 10 1k
Rx21 2 13 1k
Rx22 2 13 1k
Rx23 2 13 1k
Rx24 2 13 1k
R21 10 8 1k
R31 2 6 1k
R32 2 6 1k
R41 8 2 1k
D1 14 2 d1
D2 2 1 d1
V1 4 0 15
V2 0 11 15
V3 999 999 0
* INSTRUCTIONS: Creative mode allows you to construct, simulate and implement a circuit in any way within the constraints of the hardware. You have been provided with every node necessary for constructing the circuit. Joining nodes will produce an error.
* IMPLEMENTATION NOTES: When this lab is opened, the relay controlling the power supply (Power - Port 1 Line 3 - ON) will switch ON. Once your circuit has been constructed, it will be checked against a set of possible valid implementations. If your circuit matches, it will be implemented on the hardware
* DIGOUTPUT0_POST = 0 0 0 0 0 0 0 0
* DIGOUTPUT1_POST = 0 0 0 0 0 0 0 0
* AOUTPUT0_POST = 0.0
* AOUTPUT1_POST = 0.0
