*
R1 1 0 1k
V1 1 0 PULSE(-1 1 0 .5m .5m 10u 1m)
* INSTRUCTIONS: Configure the source to produce 5V DC, and construct a simple voltage divider circuit that produces 3V at the intermediate node. Simulate the circuit to validate your results
* ACTION FUNCTION: Familiarisation
.control
tran 1u 4m
run
print v(1)
.endc
